# Repository DaveLapp/T41

## KiCad design K9HZ_LPF_Module/K9HZ_LPF_V1.00_Schematics/K9HZ_100W_11band_LPF-Filter/K9HZ_100W_11band_LPF-Filter.kicad_pcb

Parts:
C1, C2, C13, C14, C25, C26, C37, C38, C48, C49, C57, C58, C64, C65, C75, C76, C82, C83, C89, C90, C98, C99, C105, C106: 0.1uF 50V; C_1206_0805_Dual; Mouser Part Number 581-12065F104K4
C3, C10, C23, C50, C51, C54, C55, C68, C71, C77, C80: 150pF 100V; C_1206_0805_Dual; Mouser Part Number 80-C1206C151J1G
C4, C9: 1500pF 100V; C_1206_0805_Dual; Mouser Part Number 80-C1206C152J1GECAUT
C5, C8: 2200pF 100V; C_1206_0805_Dual; Mouser Part Number 81-GRM319R72A222JA1D
C6, C7, C11, C29, C32, C39, C41, C42, C43, C44, C46, C60, C61: 330pF 100V; C_1206_0805_Dual; Mouser Part Number 581-12061A331JAT4A
C12, C24, C63: 47pF 100V; C_1206_0805_Dual; Mouser Part Number 80-C1206C470J1GAC
C15, C22: 390pF 100V; C_1206_0805_Dual; Mouser Part Number 80-C1206C391J1G
C16, C21, C28, C33, C52, C53: 470pF 100V; C_1206_0805_Dual; Mouser Part Number 80-C1206C471J1GAC
C17, C20: 1200pF 100V; C_1206_0805_Dual; Mouser Part Number 581-12061C122JAT2A
C18, C19, C40, C45, C47, C69, C70, C91, C96: 100pF 100V; C_1206_0805_Dual; Mouser Part Number 80-C1206C101J1GAULR
C27, C34: 560pF 100V; C_1206_0805_Dual; Mouser Part Number 581-12061C561JAT2A
C30, C31: 56pF 100V; C_1206_0805_Dual; Mouser Part Number 80-C1206C560J1G
C35, C56: 68pF 100V; C_1206_0805_Dual; Mouser Part Number 80-C1206C680J1G
C36, C100, C103: 60pF 100V; C_1206_0805_Dual; Mouser Part Number 80-C1206C620J1G
C59, C62, C78, C79: 220pF 100V; C_1206_0805_Dual; Mouser Part Number 80-C1206C221J1GAC
C66, C67, C72, C73, C92, C93, C94, C95: 82pF 100V; C_1206_0805_Dual; Mouser Part Number 80-C1206C820J1G
C74: 39pF 100V; C_1206_0805_Dual; Mouser Part Number 80-C1206C390J1G
C81: 33pF 100V; C_1206_0805_Dual; Mouser Part Number 80-C1206C330J1G
C84, C87: 120pF 100V; C_1206_0805_Dual; Mouser Part Number 77-VJ1206A121JXBMT
C85, C86: 180pF 100V; C_1206_0805_Dual; Mouser Part Number 80-C1206C181J1G
C88, C97: 27pF 100V; C_1206_0805_Dual; Mouser Part Number 80-C1206C270J1G
C101, C102: 91pF 100V; C_1206_0805_Dual; Mouser Part Number 80-C1206C910J1G
C104: 14pF 100V; C_1206_0805_Dual; Mouser Part Number 80-C1206C150J1G
H1, H2, H3, H4: MountingHole_3.2mm_M3_DIN965_Pad
J1, J2: RF interconnect; SMA_Amphenol_901-144_Vertical; Mouser Part Number 712-CONSMA001-G
J3: LPF CTRL LOW; IDC-Header_2x05_P2.54mm_Vertical
J4: LPF CTRL HI; IDC-Header_2x05_P2.54mm_Vertical
K1, K2, K3, K4, K5, K6, K7, K8, K9, K10, K11, K12, K13, K14, K15, K16, K17, K18, K19, K20, K21, K22, K23, K24: HF41F/12-ZS; Relay_SPDT_HF41F12-ZS
L1, L3: 5.21uH; T68-6-toroid-vertical
L2: 4.73uH; T68-6-toroid-vertical
L4, L6: 2.68uH; T68-6-toroid-vertical
L5: 2.43uH; T68-6-toroid-vertical
L7, L9: 1.76uH; T68-6-toroid-vertical
L8: 1.60uH; T68-6-toroid-vertical
L10, L12: 1.34uH; T68-6-toroid-vertical
L11: 1.22uH; T68-6-toroid-vertical
L13, L15: 0.928uH; T68-6-toroid-vertical
L14: 0.843uH; T68-6-toroid-vertical
L16, L18: 0.670uH; T68-6-toroid-vertical
L17: 0.608uH; T68-6-toroid-vertical
L19, L21: 0.519uH; T68-6-toroid-vertical
L20: 0.471uH; T68-6-toroid-vertical
L22, L24: 0.447uH; T68-6-toroid-vertical
L23: 0.406uH; T68-6-toroid-vertical
L25, L27: 0.337uH; T68-6-toroid-vertical
L26: 0.342uH; T68-6-toroid-vertical
L28, L30: 0.335uH; T68-6-toroid-vertical
L29: 0.305uH; T68-6-toroid-vertical
L31, L33: 0.188uH; T68-6-toroid-vertical
L32: 0.170uH; T68-6-toroid-vertical

Connections:
+12V: C1.1, C2.1, C13.1, C14.1, C25.1, C26.1, C37.1, C38.1, C48.1, C49.1, C57.1, C58.1, C64.1, C65.1, C75.1, C76.1, C82.1, C83.1, C89.1, C90.1, C98.1, C99.1, C105.1, C106.1, J3.2, J3.4, J4.2, J4.4, K1.A1, K2.A2, K3.A1, K4.A2, K5.A1, K6.A2, K7.A1, K8.A2, K9.A1, K10.A2, K11.A1, K12.A2, K13.A1, K14.A2, K15.A1, K16.A2, K17.A1, K18.A2, K19.A1, K20.A2, K21.A1, K22.A2, K23.A1, K24.A2
/B6M: J4.9, K21.A2, K22.A1
/B10M: J4.7, K19.A2, K20.A1
/B12M: J4.5, K17.A2, K18.A1
/B15M: J4.3, K15.A2, K16.A1
/B17M: J4.1, K13.A2, K14.A1
/B20M: J3.10, K11.A2, K12.A1
/B30M: J3.9, K9.A2, K10.A1
/B40M: J3.7, K7.A2, K8.A1
/B60M: J3.5, K5.A2, K6.A1
/B80M: J3.3, K3.A2, K4.A1
/B160M: J3.1, K1.A2, K2.A1
/BNF: J4.10, K23.A2, K24.A1
/RF1: J2.1 (In), K1.14, K3.14, K5.14, K7.14, K9.14, K11.14, K13.14, K15.14, K17.14, K19.14, K21.14, K23.14
/RF2: C3.2, C4.2, K1.11, L1.1
/RF3: C5.2, C6.2, C11.2, C12.2, L1.2, L2.1
/RF4: C7.2, C8.2, C11.1, C12.1, L2.2, L3.1
/RF5: C9.2, C10.2, K2.11, L3.2
/RF6: J1.1 (In), K2.14, K4.14, K6.14, K8.14, K10.14, K12.14, K14.14, K16.14, K18.14, K20.14, K22.14, K24.14
/RF7: C15.2, C16.2, K3.11, L4.1
/RF8: C17.2, C18.2, C23.2, C24.2, L4.2, L5.1
/RF9: C19.2, C20.2, C23.1, C24.1, L5.2, L6.1
/RF10: C21.2, C22.2, K4.11, L6.2
/RF11: C27.2, K5.11, L7.1
/RF12: C28.2, C29.2, C30.2, C35.2, C36.2, L7.2, L8.1
/RF13: C31.2, C32.2, C33.2, C35.1, C36.1, L8.2, L9.1
/RF14: C34.2, K6.11, L9.2
/RF15: C39.2, C40.2, K7.11, L10.1
/RF16: C41.2, C42.2, C47.2, L10.2, L11.1
/RF17: C43.2, C44.2, C47.1, L11.2, L12.1
/RF18: C45.2, C46.2, K8.11, L12.2
/RF19: C50.2, C51.2, K9.11, L13.1
/RF20: C52.2, C56.2, L13.2, L14.1
/RF21: C53.2, C56.1, L14.2, L15.1
/RF22: C54.2, C55.2, K10.11, L15.2
/RF23: C59.2, K11.11, L16.1
/RF24: C60.2, C63.2, L16.2, L17.1
/RF25: C61.2, C63.1, L17.2, L18.1
/RF26: C62.2, K12.11, L18.2
/RF27: C66.2, C67.2, K13.11, L19.1
/RF28: C68.2, C69.2, C74.2, L19.2, L20.1
/RF29: C70.2, C71.2, C74.1, L20.2, L21.1
/RF30: C72.2, C73.2, K14.11, L21.2
/RF31: C77.2, K15.11, L22.1
/RF32: C78.2, C81.2, L22.2, L23.1
/RF33: C79.2, C81.1, L23.2, L24.1
/RF34: C80.2, K16.11, L24.2
/RF35: C84.2, K17.11, L25.1
/RF36: C85.2, C88.2, L25.2, L26.1
/RF37: C86.2, C88.1, L26.2, L27.1
/RF38: C87.2, K18.11, L27.2
/RF39: C91.2, K19.11, L28.1
/RF40: C92.2, C93.2, C97.2, L28.2, L29.1
/RF41: C94.2, C95.2, C97.1, L29.2, L30.1
/RF42: C96.2, K20.11, L30.2
/RF43: C100.2, K21.11, L31.1
/RF44: C101.2, C104.2, L31.2, L32.1
/RF45: C102.2, C104.1, L32.2, L33.1
/RF46: C103.2, K22.11, L33.2
/RF47: K23.11, K24.11
GND: C1.2, C2.2, C3.1, C4.1, C5.1, C6.1, C7.1, C8.1, C9.1, C10.1, C13.2, C14.2, C15.1, C16.1, C17.1, C18.1, C19.1, C20.1, C21.1, C22.1, C25.2, C26.2, C27.1, C28.1, C29.1, C30.1, C31.1, C32.1, C33.1, C34.1, C37.2, C38.2, C39.1, C40.1, C41.1, C42.1, C43.1, C44.1, C45.1, C46.1, C48.2, C49.2, C50.1, C51.1, C52.1, C53.1, C54.1, C55.1, C57.2, C58.2, C59.1, C60.1, C61.1, C62.1, C64.2, C65.2, C66.1, C67.1, C68.1, C69.1, C70.1, C71.1, C72.1, C73.1, C75.2, C76.2, C77.1, C78.1, C79.1, C80.1, C82.2, C83.2, C84.1, C85.1, C86.1, C87.1, C89.2, C90.2, C91.1, C92.1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

Notes on the sheet:
Board mounting holes
6M [1010]
160M [0001]
15M [0111]
All toroids wound on T68-6 cores
10M [1001]
30M [0100]
20M [0101]
40M [0011]
60M [0000]
LPFs
17M [0110]
12M [1000]
80M [0010]
NO FILT [1111]

Board: 4 copper layers, 100.0 x 100.0 mm, 171 parts (107 on the bottom side), 61 nets.

## Commit log

2024-07-12 Changed LPF to use 1206 and 0805
    LPF has multiple changes but all to support use of either 1206 or 0805 caps
2024-07-12 Clean up
    Removed extraneous files
